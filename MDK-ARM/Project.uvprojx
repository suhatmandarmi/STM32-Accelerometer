# Keil uVision project Project.uvprojx, settings and files
target STM32F4-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4_DISCO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO
  c include: ../inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F4-Discovery;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32F4-Discovery;..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Drivers\BSP\Components\l3gd20;..\..\..\Drivers\BSP\Components\lis3dsh;..\..\..\Drivers\BSP\Components\lis302dl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio_dma.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_ll_usb.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Drivers/BSP/STM32F4_DISCO
    ../../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_accelerometer.c
    ../../../Drivers/BSP/Components/lis302dl/: lis302dl.c
    ../../../Drivers/BSP/Components/lis3dsh/: lis3dsh.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: usbh_conf.c main.c stm32f4xx_it.c
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
software components: CMSIS:CORE 4.3.0
